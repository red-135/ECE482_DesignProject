TOP LEVEL
.lib "/class/ece482/models25" FF
** Generated for: hspiceD
** Generated on: Dec  5 16:09:16 2016
** Design library name: ECE482_Project_V4
** Design cell name: top
** Design view name: extracted

** Library name: ECE482_Project_V4
** Cell name: top
** View name: extracted
m0 vdd! n72 n38 vdd! pmos L=240e-9 W=9e-6 AD=5.4e-12 AS=3.24e-12 PD=10.2e-6 PS=720e-9 M=1
m1 n38 n72 vdd! vdd! pmos L=240e-9 W=9e-6 AD=3.24e-12 AS=3.24e-12 PD=720e-9 PS=720e-9 M=1
m2 vdd! n72 n38 vdd! pmos L=240e-9 W=9e-6 AD=3.24e-12 AS=3.24e-12 PD=720e-9 PS=720e-9 M=1
m3 n38 n72 vdd! vdd! pmos L=240e-9 W=9e-6 AD=3.24e-12 AS=3.24e-12 PD=720e-9 PS=720e-9 M=1
m4 vdd! n72 n38 vdd! pmos L=240e-9 W=9e-6 AD=3.24e-12 AS=3.24e-12 PD=720e-9 PS=720e-9 M=1
m5 n38 n72 vdd! vdd! pmos L=240e-9 W=9e-6 AD=3.24e-12 AS=3.24e-12 PD=720e-9 PS=720e-9 M=1
m6 vdd! n72 n38 vdd! pmos L=240e-9 W=9e-6 AD=3.24e-12 AS=3.24e-12 PD=720e-9 PS=720e-9 M=1
m7 n38 n72 vdd! vdd! pmos L=240e-9 W=9e-6 AD=3.24e-12 AS=3.24e-12 PD=720e-9 PS=720e-9 M=1
m8 vdd! n72 n38 vdd! pmos L=240e-9 W=9e-6 AD=3.24e-12 AS=3.24e-12 PD=720e-9 PS=720e-9 M=1
m9 n38 n72 vdd! vdd! pmos L=240e-9 W=9e-6 AD=3.24e-12 AS=5.4e-12 PD=720e-9 PS=10.2e-6 M=1
m10 vdd! n71 n72 vdd! pmos L=240e-9 W=9e-6 AD=5.4e-12 AS=3.24e-12 PD=10.2e-6 PS=720e-9 M=1
m11 n72 n71 vdd! vdd! pmos L=240e-9 W=9e-6 AD=3.24e-12 AS=5.4e-12 PD=720e-9 PS=10.2e-6 M=1
c12 0 n72 455.357e-18 M=1
c13 0 n71 89.3952e-18 M=1
c14 0 n70 150.854e-18 M=1
c15 0 n69 48.888e-18 M=1
c16 0 n68 122.918e-18 M=1
c17 0 n67 115.934e-18 M=1
c18 0 n66 110.347e-18 M=1
c19 0 n65 729.13e-18 M=1
c20 0 n64 68.4432e-18 M=1
c21 0 n63 78.2208e-18 M=1
c22 0 n62 37.7136e-18 M=1
c23 0 n61 71.2368e-18 M=1
c24 0 n60 115.934e-18 M=1
c25 0 n58 110.347e-18 M=1
c26 0 n57 37.7136e-18 M=1
c27 0 n56 167.616e-18 M=1
c28 0 n55 397.39e-18 M=1
c29 0 n54 115.934e-18 M=1
c30 0 n53 136.886e-18 M=1
c31 0 n52 61.4592e-18 M=1
c32 0 n51 110.347e-18 M=1
c33 0 n49 384.12e-18 M=1
c34 0 n48 37.7136e-18 M=1
c35 0 n47 53.0784e-18 M=1
c36 0 n46 71.2368e-18 M=1
c37 0 n45 57.2688e-18 M=1
c38 0 n44 79.6176e-18 M=1
c39 0 n43 115.934e-18 M=1
c40 0 n42 177.394e-18 M=1
c41 0 n41 114.538e-18 M=1
c42 0 n40 136.886e-18 M=1
c43 0 n39 67.0464e-18 M=1
c44 0 n37 110.347e-18 M=1
c45 0 n36 41.904e-18 M=1
c46 0 n35 51.6816e-18 M=1
c47 0 n34 108.95e-18 M=1
c48 0 n33 37.7136e-18 M=1
c49 0 n32 72.6336e-18 M=1
c50 0 n30 37.7136e-18 M=1
c51 0 n29 71.2368e-18 M=1
c52 0 n28 71.2368e-18 M=1
c53 0 n27 436.5e-18 M=1
c54 0 n26 159.235e-18 M=1
c55 0 n25 71.2368e-18 M=1
c56 0 n24 268.186e-18 M=1
c57 0 n23 223.488e-18 M=1
c58 0 n22 115.934e-18 M=1
c59 0 n21 576.878e-18 M=1
c60 0 n20 314.28e-18 M=1
c61 0 n19 219.298e-18 M=1
c62 0 n18 428.818e-18 M=1
c63 0 n17 406.469e-18 M=1
c64 0 n16 58.6656e-18 M=1
c65 0 n15 61.4592e-18 M=1
c66 0 n14 110.347e-18 M=1
c67 0 n13 60.7608e-18 M=1
c68 0 n12 61.4592e-18 M=1
c69 0 n11 58.6656e-18 M=1
c70 0 n10 58.6656e-18 M=1
c71 0 n9 58.6656e-18 M=1
c72 0 n8 37.7136e-18 M=1
c73 0 rst 47.4912e-18 M=1
c74 clk 0 1.05039e-15 M=1
c75 vdd! n72 318.47e-18 M=1
c76 vdd! n71 50.2848e-18 M=1
c77 vdd! n70 47.4912e-18 M=1
c78 vdd! n69 34.92e-18 M=1
c79 vdd! n68 47.4912e-18 M=1
c80 vdd! n67 33.5232e-18 M=1
c81 vdd! n66 23.7456e-18 M=1
c82 vdd! n65 332.438e-18 M=1
c83 vdd! n64 23.7456e-18 M=1
c84 vdd! n63 55.872e-18 M=1
c85 vdd! n61 34.92e-18 M=1
c86 vdd! n60 33.5232e-18 M=1
c87 vdd! n58 23.7456e-18 M=1
c88 vdd! n56 92.1888e-18 M=1
c89 vdd! n55 362.47e-18 M=1
c90 vdd! n54 33.5232e-18 M=1
c91 vdd! n53 53.0784e-18 M=1
c92 vdd! n52 25.1424e-18 M=1
c93 vdd! n51 23.7456e-18 M=1
c94 vdd! n49 118.728e-18 M=1
c95 vdd! n47 23.7456e-18 M=1
c96 vdd! n46 34.92e-18 M=1
c97 vdd! n45 43.3008e-18 M=1
c98 vdd! n44 23.7456e-18 M=1
c99 vdd! n43 33.5232e-18 M=1
c100 vdd! n42 277.963e-18 M=1
c101 vdd! n41 34.92e-18 M=1
c102 vdd! n40 23.7456e-18 M=1
c103 vdd! n39 67.0464e-18 M=1
c104 vdd! n37 23.7456e-18 M=1
c105 vdd! n36 33.5232e-18 M=1
c106 vdd! n35 43.3008e-18 M=1
c107 vdd! n34 25.1424e-18 M=1
c108 vdd! n32 23.7456e-18 M=1
c109 vdd! n29 34.92e-18 M=1
c110 vdd! n28 34.92e-18 M=1
c111 vdd! n25 34.92e-18 M=1
c112 vdd! n24 47.4912e-18 M=1
c113 vdd! n23 47.4912e-18 M=1
c114 vdd! n22 33.5232e-18 M=1
c115 vdd! n19 71.2368e-18 M=1
c116 vdd! n18 94.9824e-18 M=1
c117 vdd! n17 94.9824e-18 M=1
c118 vdd! n16 607.608e-18 M=1
c119 vdd! n15 329.645e-18 M=1
c120 vdd! n14 23.7456e-18 M=1
c121 vdd! n13 430.913e-18 M=1
c122 vdd! n12 177.394e-18 M=1
c123 vdd! n11 32.1264e-18 M=1
c124 vdd! n10 32.1264e-18 M=1
c125 vdd! n9 32.1264e-18 M=1
c126 vdd! rst 23.7456e-18 M=1
c127 vdd! 0 149.458e-18 M=1
c128 vdd! clk 319.867e-18 M=1
c129 c2 0 47.4912e-18 M=1
c130 c2 vdd! 23.7456e-18 M=1
c131 c1 0 47.4912e-18 M=1
c132 c1 vdd! 23.7456e-18 M=1
c133 n71 n72 173.208e-18 M=1
c134 n70 n71 191.822e-18 M=1
c135 n68 n73 89.4432e-18 M=1
c136 n68 n69 89.4432e-18 M=1
c137 n63 n65 180.928e-18 M=1
c138 n59 n65 2.19287e-15 M=1
c139 n56 n73 89.4432e-18 M=1
c140 n56 n69 178.886e-18 M=1
c141 n53 n55 188.194e-18 M=1
c142 n50 n55 1.44829e-15 M=1
c143 n49 n62 89.4432e-18 M=1
c144 n49 n61 126.672e-18 M=1
c145 n49 n57 89.4432e-18 M=1
c146 n49 n56 126.672e-18 M=1
c147 n48 n49 89.4432e-18 M=1
c148 n46 n49 126.672e-18 M=1
c149 n44 n47 89.4432e-18 M=1
c150 n39 n42 173.208e-18 M=1
c151 n38 n72 1.44829e-15 M=1
c152 n33 n49 89.4432e-18 M=1
c153 n31 n42 1.17776e-15 M=1
c154 n29 n49 126.672e-18 M=1
c155 n28 n73 25.92e-18 M=1
c156 n28 n69 178.886e-18 M=1
c157 n28 n56 89.4432e-18 M=1
c158 n28 n49 135.526e-18 M=1
c159 n24 n32 89.4432e-18 M=1
c160 n19 n44 89.4432e-18 M=1
c161 n18 n40 89.4432e-18 M=1
c162 n18 n35 69.9216e-18 M=1
c163 n18 n32 89.4432e-18 M=1
c164 n17 n40 89.4432e-18 M=1
c165 n17 n32 178.886e-18 M=1
c166 n17 n24 89.4432e-18 M=1
c167 n16 n18 89.4432e-18 M=1
c168 n15 n18 123.95e-18 M=1
c169 n13 n24 89.4432e-18 M=1
c170 n12 n24 89.4432e-18 M=1
c171 n11 n19 178.886e-18 M=1
c172 n10 n18 178.886e-18 M=1
c173 n9 n17 178.886e-18 M=1
c174 n8 n49 89.4432e-18 M=1
c175 0 n72 1.02585e-15 M=1
c176 0 n71 202.553e-18 M=1
c177 0 n70 97.0272e-18 M=1
c178 0 n69 147.931e-18 M=1
c179 0 n68 316.699e-18 M=1
c180 0 n67 293.549e-18 M=1
c181 0 n66 264.979e-18 M=1
c182 0 n65 1.01469e-15 M=1
c183 0 n64 87.1296e-18 M=1
c184 0 n63 311.436e-18 M=1
c185 0 n62 255.058e-18 M=1
c186 0 n61 272.141e-18 M=1
c187 0 n60 293.549e-18 M=1
c188 0 n59 748.2e-18 M=1
c189 0 n58 264.979e-18 M=1
c190 0 n57 255.058e-18 M=1
c191 0 n56 339.403e-18 M=1
c192 0 n55 1.06858e-15 M=1
c193 0 n54 293.549e-18 M=1
c194 0 n53 101.381e-18 M=1
c195 0 n52 317.906e-18 M=1
c196 0 n51 264.979e-18 M=1
c197 0 n50 353.155e-18 M=1
c198 0 n49 437.126e-18 M=1
c199 0 n48 255.058e-18 M=1
c200 0 n47 141.828e-18 M=1
c201 0 n46 272.141e-18 M=1
c202 0 n45 206.093e-18 M=1
c203 0 n44 308.246e-18 M=1
c204 0 n43 293.549e-18 M=1
c205 0 n42 102.386e-18 M=1
c206 0 n41 288.19e-18 M=1
c207 0 n40 252.096e-18 M=1
c208 0 n39 103.469e-18 M=1
c209 0 n38 349.526e-18 M=1
c210 0 n37 264.979e-18 M=1
c211 0 n36 153.19e-18 M=1
c212 0 n35 394.733e-18 M=1
c213 0 n34 261.398e-18 M=1
c214 0 n33 255.058e-18 M=1
c215 0 n32 426.574e-18 M=1
c216 0 n31 353.146e-18 M=1
c217 0 n30 344.501e-18 M=1
c218 0 n29 272.141e-18 M=1
c219 0 n28 262.886e-18 M=1
c220 0 n27 104.052e-18 M=1
c221 0 n26 114.199e-18 M=1
c222 0 n25 177.346e-18 M=1
c223 0 n24 627.062e-18 M=1
c224 0 n23 365.849e-18 M=1
c225 0 n22 293.549e-18 M=1
c226 0 n21 96.432e-18 M=1
c227 0 n20 100.037e-18 M=1
c228 0 n19 416.443e-18 M=1
c229 0 n18 951.917e-18 M=1
c230 0 n17 946.949e-18 M=1
c231 0 n16 197.753e-18 M=1
c232 0 n15 273.605e-18 M=1
c233 0 n14 264.979e-18 M=1
c234 0 n13 282.919e-18 M=1
c235 0 n12 272.587e-18 M=1
c236 0 n11 168.036e-18 M=1
c237 0 n10 168.036e-18 M=1
c238 0 n9 168.036e-18 M=1
c239 0 n8 255.058e-18 M=1
c240 0 rst 44.088e-18 M=1
c241 clk n62 42.9072e-18 M=1
c242 clk n57 42.9072e-18 M=1
c243 clk n49 300.804e-18 M=1
c244 clk n48 42.9072e-18 M=1
c245 clk n33 42.9072e-18 M=1
c246 clk n30 42.9072e-18 M=1
c247 clk n8 42.9072e-18 M=1
c248 clk 0 774.588e-18 M=1
c249 d n27 742.56e-18 M=1
c250 d n26 206.808e-18 M=1
c251 d n21 940.514e-18 M=1
c252 d n20 432.23e-18 M=1
c253 d n16 845.846e-18 M=1
c254 d n15 432.23e-18 M=1
c255 d n13 639.038e-18 M=1
c256 d n12 206.808e-18 M=1
c257 d 0 3.22708e-15 M=1
c258 vdd! n72 51.2496e-18 M=1
c259 vdd! n71 96.2064e-18 M=1
c260 vdd! n70 22.056e-18 M=1
c261 vdd! n69 190.342e-18 M=1
c262 vdd! n68 157.438e-18 M=1
c263 vdd! n67 113.95e-18 M=1
c264 vdd! n66 51.2496e-18 M=1
c265 vdd! n65 144.47e-18 M=1
c266 vdd! n64 22.056e-18 M=1
c267 vdd! n63 134.762e-18 M=1
c268 vdd! n62 74.9352e-18 M=1
c269 vdd! n61 70.5336e-18 M=1
c270 vdd! n60 113.95e-18 M=1
c271 vdd! n59 441.034e-18 M=1
c272 vdd! n58 51.2496e-18 M=1
c273 vdd! n57 74.9352e-18 M=1
c274 vdd! n56 118.524e-18 M=1
c275 vdd! n55 118.488e-18 M=1
c276 vdd! n54 113.95e-18 M=1
c277 vdd! n53 94.2072e-18 M=1
c278 vdd! n52 85.1544e-18 M=1
c279 vdd! n51 51.2496e-18 M=1
c280 vdd! n50 295.339e-18 M=1
c281 vdd! n49 51.2496e-18 M=1
c282 vdd! n48 74.9352e-18 M=1
c283 vdd! n47 171.878e-18 M=1
c284 vdd! n46 70.5336e-18 M=1
c285 vdd! n45 94.2432e-18 M=1
c286 vdd! n44 110.518e-18 M=1
c287 vdd! n43 113.95e-18 M=1
c288 vdd! n42 102.386e-18 M=1
c289 vdd! n41 119.309e-18 M=1
c290 vdd! n40 72.7464e-18 M=1
c291 vdd! n39 81.984e-18 M=1
c292 vdd! n38 228.576e-18 M=1
c293 vdd! n37 51.2496e-18 M=1
c294 vdd! n36 85.1544e-18 M=1
c295 vdd! n35 69.1896e-18 M=1
c296 vdd! n34 54.8304e-18 M=1
c297 vdd! n33 74.9352e-18 M=1
c298 vdd! n32 39.1632e-18 M=1
c299 vdd! n31 262.332e-18 M=1
c300 vdd! n30 74.9352e-18 M=1
c301 vdd! n29 70.5336e-18 M=1
c302 vdd! n28 90.3096e-18 M=1
c303 vdd! n27 73.8408e-18 M=1
c304 vdd! n26 86.6232e-18 M=1
c305 vdd! n25 51.2496e-18 M=1
c306 vdd! n24 66.108e-18 M=1
c307 vdd! n23 61.1472e-18 M=1
c308 vdd! n22 113.95e-18 M=1
c309 vdd! n21 69.4392e-18 M=1
c310 vdd! n20 66.5304e-18 M=1
c311 vdd! n19 144.077e-18 M=1
c312 vdd! n18 298.039e-18 M=1
c313 vdd! n17 112.349e-18 M=1
c314 vdd! n16 203.88e-18 M=1
c315 vdd! n15 212.386e-18 M=1
c316 vdd! n14 51.2496e-18 M=1
c317 vdd! n13 158.174e-18 M=1
c318 vdd! n12 134.875e-18 M=1
c319 vdd! n11 243.66e-18 M=1
c320 vdd! n10 243.66e-18 M=1
c321 vdd! n9 243.66e-18 M=1
c322 vdd! n8 74.9352e-18 M=1
c323 vdd! 0 5.70337e-15 M=1
c324 vdd! clk 231.48e-18 M=1
c325 vdd! d 868.822e-18 M=1
c326 c2 0 44.088e-18 M=1
c327 c1 0 44.088e-18 M=1
c328 n68 n69 208.358e-18 M=1
c329 n59 n65 644.544e-18 M=1
c330 n56 n69 79.6752e-18 M=1
c331 n56 n68 204.062e-18 M=1
c332 n56 n67 308.036e-18 M=1
c333 n56 n66 260.652e-18 M=1
c334 n56 n62 94.6176e-18 M=1
c335 n56 n61 131.544e-18 M=1
c336 n56 n60 257.459e-18 M=1
c337 n56 n58 260.652e-18 M=1
c338 n56 n57 94.6176e-18 M=1
c339 n50 n55 466.819e-18 M=1
c340 n49 n61 121.464e-18 M=1
c341 n49 n60 131.544e-18 M=1
c342 n49 n58 131.544e-18 M=1
c343 n49 n57 172.896e-18 M=1
c344 n49 n56 225.202e-18 M=1
c345 n49 n54 131.544e-18 M=1
c346 n49 n51 131.544e-18 M=1
c347 n48 n49 172.896e-18 M=1
c348 n47 n49 172.98e-18 M=1
c349 n46 n49 121.464e-18 M=1
c350 n45 n65 236.952e-18 M=1
c351 n45 n64 57.1536e-18 M=1
c352 n45 n63 321.091e-18 M=1
c353 n45 n55 674.611e-18 M=1
c354 n45 n53 216.374e-18 M=1
c355 n45 n52 57.1536e-18 M=1
c356 n45 n50 515.376e-18 M=1
c357 n43 n49 131.544e-18 M=1
c358 n38 n72 48.4308e-18 M=1
c359 n38 n59 925.661e-18 M=1
c360 n38 n50 719.51e-18 M=1
c361 n37 n49 131.544e-18 M=1
c362 n35 n65 617.458e-18 M=1
c363 n35 n64 57.1536e-18 M=1
c364 n35 n63 208.194e-18 M=1
c365 n35 n59 537.221e-18 M=1
c366 n35 n55 673.502e-18 M=1
c367 n35 n53 216.374e-18 M=1
c368 n35 n52 57.1536e-18 M=1
c369 n35 n50 511.056e-18 M=1
c370 n35 n45 88.1544e-18 M=1
c371 n35 n40 558.331e-18 M=1
c372 n33 n49 172.896e-18 M=1
c373 n31 n42 503.15e-18 M=1
c374 n31 n39 216.374e-18 M=1
c375 n31 n36 136.872e-18 M=1
c376 n31 n32 57.1536e-18 M=1
c377 n29 n49 121.464e-18 M=1
c378 n28 n69 65.1072e-18 M=1
c379 n28 n68 237.106e-18 M=1
c380 n28 n67 184.147e-18 M=1
c381 n28 n66 186.302e-18 M=1
c382 n28 n62 131.544e-18 M=1
c383 n28 n61 131.544e-18 M=1
c384 n28 n60 152.438e-18 M=1
c385 n28 n58 186.302e-18 M=1
c386 n28 n57 131.544e-18 M=1
c387 n28 n56 235.282e-18 M=1
c388 n28 n54 152.438e-18 M=1
c389 n28 n51 186.302e-18 M=1
c390 n28 n49 280.483e-18 M=1
c391 n28 n48 131.544e-18 M=1
c392 n28 n46 131.544e-18 M=1
c393 n28 n43 152.438e-18 M=1
c394 n28 n40 94.6176e-18 M=1
c395 n28 n37 186.302e-18 M=1
c396 n28 n35 96.0576e-18 M=1
c397 n28 n33 157.037e-18 M=1
c398 n28 n32 95.3376e-18 M=1
c399 n28 n29 131.544e-18 M=1
c400 n27 n55 30.7296e-18 M=1
c401 n27 n50 622.426e-18 M=1
c402 n27 n38 685.843e-18 M=1
c403 n26 n31 207.475e-18 M=1
c404 n24 n32 67.2336e-18 M=1
c405 n24 n28 103.738e-18 M=1
c406 n23 n28 103.738e-18 M=1
c407 n23 n24 57.1536e-18 M=1
c408 n22 n49 131.544e-18 M=1
c409 n22 n28 152.438e-18 M=1
c410 n21 n65 404.147e-18 M=1
c411 n21 n63 114.307e-18 M=1
c412 n21 n59 1.1529e-15 M=1
c413 n21 n55 674.611e-18 M=1
c414 n21 n53 114.307e-18 M=1
c415 n21 n50 515.376e-18 M=1
c416 n21 n42 503.15e-18 M=1
c417 n21 n39 114.307e-18 M=1
c418 n21 n38 914.458e-18 M=1
c419 n21 n31 411.293e-18 M=1
c420 n20 n38 509.568e-18 M=1
c421 n20 n31 284.717e-18 M=1
c422 n19 n44 79.6752e-18 M=1
c423 n19 n41 214.396e-18 M=1
c424 n19 n34 251.035e-18 M=1
c425 n19 n30 134.455e-18 M=1
c426 n19 n25 51.8688e-18 M=1
c427 n18 n35 98.9424e-18 M=1
c428 n18 n28 51.8688e-18 M=1
c429 n18 n24 460.493e-18 M=1
c430 n17 n35 41.7888e-18 M=1
c431 n17 n32 30.7296e-18 M=1
c432 n17 n28 51.8688e-18 M=1
c433 n17 n24 57.1536e-18 M=1
c434 n16 n59 829.901e-18 M=1
c435 n16 n55 461.668e-18 M=1
c436 n16 n53 114.307e-18 M=1
c437 n16 n50 309.226e-18 M=1
c438 n16 n42 503.15e-18 M=1
c439 n16 n39 216.374e-18 M=1
c440 n16 n36 57.1536e-18 M=1
c441 n16 n31 411.293e-18 M=1
c442 n16 n17 165.611e-18 M=1
c443 n15 n38 627.931e-18 M=1
c444 n15 n31 270.553e-18 M=1
c445 n15 n26 282.391e-18 M=1
c446 n15 n20 119.225e-18 M=1
c447 n14 n49 131.544e-18 M=1
c448 n14 n28 186.302e-18 M=1
c449 n13 n50 746.042e-18 M=1
c450 n13 n38 324.96e-18 M=1
c451 n13 n31 262.224e-18 M=1
c452 n13 n27 86.7144e-18 M=1
c453 n13 n18 51.8688e-18 M=1
c454 n13 n17 138.583e-18 M=1
c455 n13 n16 178.152e-18 M=1
c456 n13 n15 457.229e-18 M=1
c457 n12 n31 243.918e-18 M=1
c458 n12 n23 138.583e-18 M=1
c459 n12 n20 207.475e-18 M=1
c460 n12 n18 51.8688e-18 M=1
c461 n12 n15 172.867e-18 M=1
c462 n12 n13 228.614e-18 M=1
c463 n10 n24 281.141e-18 M=1
c464 n10 n18 25.5672e-18 M=1
c465 n9 n17 259.978e-18 M=1
c466 n8 n49 172.896e-18 M=1
c467 n8 n28 131.544e-18 M=1
c468 0 n75 414.36e-18 M=1
c469 0 n74 138.12e-18 M=1
c470 0 n70 80.4996e-18 M=1
c471 0 n68 176.861e-18 M=1
c472 0 n56 1.31041e-15 M=1
c473 0 n49 3.78891e-15 M=1
c474 0 n45 1.02837e-15 M=1
c475 0 n38 1.5254e-15 M=1
c476 0 n35 1.6361e-15 M=1
c477 0 n32 1.27225e-15 M=1
c478 0 n30 187.374e-18 M=1
c479 0 n28 5.09991e-15 M=1
c480 0 n26 560.844e-18 M=1
c481 0 n24 106.11e-18 M=1
c482 0 n23 1.56681e-15 M=1
c483 0 n20 919.282e-18 M=1
c484 0 n19 546.793e-18 M=1
c485 0 n18 141.725e-18 M=1
c486 0 n17 1.63555e-15 M=1
c487 0 n16 203.976e-18 M=1
c488 0 n15 544.511e-18 M=1
c489 0 n13 867.415e-18 M=1
c490 0 n12 1.22258e-15 M=1
c491 clk n66 131.544e-18 M=1
c492 clk n62 79.6752e-18 M=1
c493 clk n61 172.843e-18 M=1
c494 clk n60 241.387e-18 M=1
c495 clk n58 131.544e-18 M=1
c496 clk n57 79.6752e-18 M=1
c497 clk n56 380.318e-18 M=1
c498 clk n54 241.387e-18 M=1
c499 clk n51 131.544e-18 M=1
c500 clk n49 581.371e-18 M=1
c501 clk n48 79.6752e-18 M=1
c502 clk n46 172.843e-18 M=1
c503 clk n43 241.387e-18 M=1
c504 clk n37 131.544e-18 M=1
c505 clk n34 131.544e-18 M=1
c506 clk n33 79.6752e-18 M=1
c507 clk n30 79.6752e-18 M=1
c508 clk n29 172.843e-18 M=1
c509 clk n28 518.688e-18 M=1
c510 clk n22 241.387e-18 M=1
c511 clk n19 103.738e-18 M=1
c512 clk n14 131.544e-18 M=1
c513 clk n8 79.6752e-18 M=1
c514 clk 0 2.50996e-15 M=1
c515 d n59 1.68037e-15 M=1
c516 d n50 1.51093e-15 M=1
c517 d n38 2.44242e-15 M=1
c518 d n31 397.114e-18 M=1
c519 d n26 180.468e-18 M=1
c520 d n20 688.594e-18 M=1
c521 d n16 166.176e-18 M=1
c522 d n15 470.17e-18 M=1
c523 d n13 810.835e-18 M=1
c524 d 0 73.0944e-18 M=1
c525 vdd! n59 516.816e-18 M=1
c526 vdd! n56 1.86325e-15 M=1
c527 vdd! n50 873.907e-18 M=1
c528 vdd! n45 1.76344e-15 M=1
c529 vdd! n40 1.03323e-15 M=1
c530 vdd! n35 2.66767e-15 M=1
c531 vdd! n32 329.89e-18 M=1
c532 vdd! n31 1.13305e-15 M=1
c533 vdd! n27 4.15058e-15 M=1
c534 vdd! n26 59.652e-18 M=1
c535 vdd! n24 384.92e-18 M=1
c536 vdd! n23 36.4104e-18 M=1
c537 vdd! n21 4.49866e-15 M=1
c538 vdd! n20 173.808e-18 M=1
c539 vdd! n19 1.0052e-15 M=1
c540 vdd! n18 713.732e-18 M=1
c541 vdd! n16 3.80874e-15 M=1
c542 vdd! n15 859.894e-18 M=1
c543 vdd! n13 859.435e-18 M=1
c544 vdd! clk 1.79801e-15 M=1
c545 vdd! d 441.857e-18 M=1
c546 c1 n17 51.8688e-18 M=1
c547 n63 n64 500.868e-18 M=1
c548 n59 n65 123.264e-18 M=1
c549 n48 n49 39.9168e-18 M=1
c550 n47 n49 54.756e-18 M=1
c551 n46 n49 102.42e-18 M=1
c552 n45 n65 952.978e-18 M=1
c553 n45 n64 486.259e-18 M=1
c554 n45 n63 894.816e-18 M=1
c555 n35 n71 752.112e-18 M=1
c556 n35 n70 81.216e-18 M=1
c557 n35 n64 89.0232e-18 M=1
c558 n35 n59 1.10482e-15 M=1
c559 n35 n45 89.0232e-18 M=1
c560 n32 n35 182.138e-18 M=1
c561 n28 n49 110.009e-18 M=1
c562 n28 n35 157.67e-18 M=1
c563 n28 n30 304.344e-18 M=1
c564 n27 n50 664.133e-18 M=1
c565 n27 n31 75.4848e-18 M=1
c566 n26 n31 112.349e-18 M=1
c567 n24 n75 89.0232e-18 M=1
c568 n24 n35 153.756e-18 M=1
c569 n24 n32 53.784e-18 M=1
c570 n23 n35 53.784e-18 M=1
c571 n23 n28 62.532e-18 M=1
c572 n23 n24 281.657e-18 M=1
c573 n21 n65 89.46e-18 M=1
c574 n21 n59 717.055e-18 M=1
c575 n21 n31 82.1856e-18 M=1
c576 n21 n23 82.1856e-18 M=1
c577 n20 n38 75.4848e-18 M=1
c578 n20 n31 75.4848e-18 M=1
c579 n20 n23 157.67e-18 M=1
c580 n19 n75 439.452e-18 M=1
c581 n19 n28 75.4848e-18 M=1
c582 n18 n75 556.102e-18 M=1
c583 n18 n28 53.784e-18 M=1
c584 n18 n24 82.1856e-18 M=1
c585 n18 n23 75.4848e-18 M=1
c586 n17 n75 442.162e-18 M=1
c587 n17 n35 104.832e-18 M=1
c588 n17 n32 109.078e-18 M=1
c589 n17 n24 157.67e-18 M=1
c590 n17 n23 82.1856e-18 M=1
c591 n17 n18 129.269e-18 M=1
c592 n16 n75 922.577e-18 M=1
c593 n16 n59 119.05e-18 M=1
c594 n16 n55 234.54e-18 M=1
c595 n16 n50 377.674e-18 M=1
c596 n16 n31 82.1856e-18 M=1
c597 n16 n23 82.1856e-18 M=1
c598 n16 n21 89.0232e-18 M=1
c599 n16 n18 135e-18 M=1
c600 n15 n38 36.864e-18 M=1
c601 n15 n31 138.799e-18 M=1
c602 n15 n20 358.74e-18 M=1
c603 n13 n75 82.1856e-18 M=1
c604 n13 n50 527.428e-18 M=1
c605 n13 n31 82.1856e-18 M=1
c606 n13 n24 136.879e-18 M=1
c607 n13 n23 240.132e-18 M=1
c608 n13 n18 75.4848e-18 M=1
c609 n12 n31 36.864e-18 M=1
c610 n12 n20 82.1856e-18 M=1
c611 n12 n18 75.4848e-18 M=1
c612 n10 n24 343.548e-18 M=1
c613 n10 n18 315.432e-18 M=1
c614 n9 n24 380.7e-18 M=1
c615 n9 n18 331.776e-18 M=1
c616 0 n75 939.743e-18 M=1
c617 0 n70 676.958e-18 M=1
c618 0 n64 319.332e-18 M=1
c619 0 n59 69.1656e-18 M=1
c620 0 n50 69.1656e-18 M=1
c621 0 n49 271.722e-18 M=1
c622 0 n45 38.0832e-18 M=1
c623 0 n38 188.179e-18 M=1
c624 0 n35 716.435e-18 M=1
c625 0 n32 646.834e-18 M=1
c626 0 n31 398.203e-18 M=1
c627 0 n28 588.959e-18 M=1
c628 0 n27 34.1616e-18 M=1
c629 0 n24 779.93e-18 M=1
c630 0 n23 1.12972e-15 M=1
c631 0 n21 37.6152e-18 M=1
c632 0 n20 326.945e-18 M=1
c633 0 n18 1.01887e-15 M=1
c634 0 n17 176.789e-18 M=1
c635 0 n16 69.4464e-18 M=1
c636 clk n49 75.4848e-18 M=1
c637 clk n33 84.402e-18 M=1
c638 clk n28 150.97e-18 M=1
c639 clk 0 438.066e-18 M=1
c640 d n59 58.428e-18 M=1
c641 d n50 58.428e-18 M=1
c642 d n38 53.784e-18 M=1
c643 d n31 53.784e-18 M=1
c644 d n27 75.4848e-18 M=1
c645 d n20 326.516e-18 M=1
c646 d n16 507.684e-18 M=1
c647 d n13 89.0232e-18 M=1
c648 vdd! n75 493.009e-18 M=1
c649 vdd! n70 772.841e-18 M=1
c650 vdd! n64 565.93e-18 M=1
c651 vdd! n59 396.581e-18 M=1
c652 vdd! n50 284.383e-18 M=1
c653 vdd! n49 82.1856e-18 M=1
c654 vdd! n45 52.0848e-18 M=1
c655 vdd! n38 76.1664e-18 M=1
c656 vdd! n35 1.03155e-15 M=1
c657 vdd! n32 92.268e-18 M=1
c658 vdd! n31 650.686e-18 M=1
c659 vdd! n28 379.087e-18 M=1
c660 vdd! n27 125.172e-18 M=1
c661 vdd! n24 433.813e-18 M=1
c662 vdd! n23 821.696e-18 M=1
c663 vdd! n21 544.636e-18 M=1
c664 vdd! n20 86.3508e-18 M=1
c665 vdd! n19 378e-18 M=1
c666 vdd! n18 831.432e-18 M=1
c667 vdd! n17 1.41978e-15 M=1
c668 vdd! n16 188.832e-18 M=1
c669 vdd! n13 420.808e-18 M=1
c670 vdd! n12 289.907e-18 M=1
c671 vdd! n11 60.2424e-18 M=1
c672 vdd! n10 59.6376e-18 M=1
c673 vdd! n9 59.6376e-18 M=1
c674 vdd! n8 257.796e-18 M=1
c675 vdd! 0 2.1615e-15 M=1
c676 vdd! clk 118.286e-18 M=1
c677 c1 n17 53.784e-18 M=1
m678 0 n72 n38 0 nmos L=240e-9 W=4.5e-6 AD=2.7e-12 AS=1.62e-12 PD=5.7e-6 PS=720e-9 M=1
m679 n38 n72 0 0 nmos L=240e-9 W=4.5e-6 AD=1.62e-12 AS=1.62e-12 PD=720e-9 PS=720e-9 M=1
m680 0 n72 n38 0 nmos L=240e-9 W=4.5e-6 AD=1.62e-12 AS=1.62e-12 PD=720e-9 PS=720e-9 M=1
m681 n38 n72 0 0 nmos L=240e-9 W=4.5e-6 AD=1.62e-12 AS=1.62e-12 PD=720e-9 PS=720e-9 M=1
m682 0 n72 n38 0 nmos L=240e-9 W=4.5e-6 AD=1.62e-12 AS=1.62e-12 PD=720e-9 PS=720e-9 M=1
m683 n38 n72 0 0 nmos L=240e-9 W=4.5e-6 AD=1.62e-12 AS=1.62e-12 PD=720e-9 PS=720e-9 M=1
m684 0 n72 n38 0 nmos L=240e-9 W=4.5e-6 AD=1.62e-12 AS=1.62e-12 PD=720e-9 PS=720e-9 M=1
m685 n38 n72 0 0 nmos L=240e-9 W=4.5e-6 AD=1.62e-12 AS=1.62e-12 PD=720e-9 PS=720e-9 M=1
m686 0 n72 n38 0 nmos L=240e-9 W=4.5e-6 AD=1.62e-12 AS=1.62e-12 PD=720e-9 PS=720e-9 M=1
m687 n38 n72 0 0 nmos L=240e-9 W=4.5e-6 AD=1.62e-12 AS=2.7e-12 PD=720e-9 PS=5.7e-6 M=1
m688 0 n71 n72 0 nmos L=240e-9 W=4.5e-6 AD=2.7e-12 AS=1.62e-12 PD=5.7e-6 PS=720e-9 M=1
m689 n72 n71 0 0 nmos L=240e-9 W=4.5e-6 AD=1.62e-12 AS=2.7e-12 PD=720e-9 PS=5.7e-6 M=1
m690 0 n65 n59 0 nmos L=240e-9 W=7.08e-6 AD=4.248e-12 AS=2.5488e-12 PD=8.28e-6 PS=720e-9 M=1
m691 n59 n65 0 0 nmos L=240e-9 W=7.08e-6 AD=2.5488e-12 AS=2.5488e-12 PD=720e-9 PS=720e-9 M=1
m692 0 n65 n59 0 nmos L=240e-9 W=7.08e-6 AD=2.5488e-12 AS=2.5488e-12 PD=720e-9 PS=720e-9 M=1
m693 n59 n65 0 0 nmos L=240e-9 W=7.08e-6 AD=2.5488e-12 AS=2.5488e-12 PD=720e-9 PS=720e-9 M=1
m694 0 n65 n59 0 nmos L=240e-9 W=7.08e-6 AD=2.5488e-12 AS=2.5488e-12 PD=720e-9 PS=720e-9 M=1
m695 n59 n65 0 0 nmos L=240e-9 W=7.08e-6 AD=2.5488e-12 AS=2.5488e-12 PD=720e-9 PS=720e-9 M=1
m696 0 n65 n59 0 nmos L=240e-9 W=7.08e-6 AD=2.5488e-12 AS=2.5488e-12 PD=720e-9 PS=720e-9 M=1
m697 n59 n65 0 0 nmos L=240e-9 W=7.08e-6 AD=2.5488e-12 AS=2.5488e-12 PD=720e-9 PS=720e-9 M=1
m698 0 n65 n59 0 nmos L=240e-9 W=7.08e-6 AD=2.5488e-12 AS=2.5488e-12 PD=720e-9 PS=720e-9 M=1
m699 n59 n65 0 0 nmos L=240e-9 W=7.08e-6 AD=2.5488e-12 AS=2.5488e-12 PD=720e-9 PS=720e-9 M=1
m700 0 n65 n59 0 nmos L=240e-9 W=7.08e-6 AD=2.5488e-12 AS=2.5488e-12 PD=720e-9 PS=720e-9 M=1
m701 n59 n65 0 0 nmos L=240e-9 W=7.08e-6 AD=2.5488e-12 AS=2.5488e-12 PD=720e-9 PS=720e-9 M=1
m702 0 n65 n59 0 nmos L=240e-9 W=7.08e-6 AD=2.5488e-12 AS=2.5488e-12 PD=720e-9 PS=720e-9 M=1
m703 n59 n65 0 0 nmos L=240e-9 W=7.08e-6 AD=2.5488e-12 AS=4.248e-12 PD=720e-9 PS=8.28e-6 M=1
m704 0 n69 n28 0 nmos L=240e-9 W=360e-9 AD=273.6e-15 AS=237.6e-15 PD=1.8e-6 PS=900e-9 M=1
m705 0 n56 n69 0 nmos L=240e-9 W=360e-9 AD=273.6e-15 AS=158.4e-15 PD=1.8e-6 PS=840e-9 M=1
m706 n70 n35 0 0 nmos L=240e-9 W=360e-9 AD=273.6e-15 AS=273.6e-15 PD=1.8e-6 PS=1.8e-6 M=1
m707 n69 n68 0 0 nmos L=240e-9 W=360e-9 AD=158.4e-15 AS=273.6e-15 PD=840e-9 PS=1.8e-6 M=1
m708 n68 n67 0 0 nmos L=240e-9 W=360e-9 AD=273.6e-15 AS=273.6e-15 PD=1.8e-6 PS=1.8e-6 M=1
m709 0 n49 n62 0 nmos L=240e-9 W=360e-9 AD=273.6e-15 AS=158.4e-15 PD=1.8e-6 PS=840e-9 M=1
m710 n64 n45 0 0 nmos L=240e-9 W=360e-9 AD=273.6e-15 AS=273.6e-15 PD=1.8e-6 PS=1.8e-6 M=1
m711 n62 n61 0 0 nmos L=240e-9 W=360e-9 AD=158.4e-15 AS=273.6e-15 PD=840e-9 PS=1.8e-6 M=1
m712 n61 n60 0 0 nmos L=240e-9 W=360e-9 AD=273.6e-15 AS=273.6e-15 PD=1.8e-6 PS=1.8e-6 M=1
m713 0 n49 n57 0 nmos L=240e-9 W=360e-9 AD=273.6e-15 AS=158.4e-15 PD=1.8e-6 PS=840e-9 M=1
m714 n57 n56 0 0 nmos L=240e-9 W=360e-9 AD=158.4e-15 AS=273.6e-15 PD=840e-9 PS=1.8e-6 M=1
m715 n56 n54 0 0 nmos L=240e-9 W=360e-9 AD=273.6e-15 AS=273.6e-15 PD=1.8e-6 PS=1.8e-6 M=1
m716 n52 n40 0 0 nmos L=240e-9 W=360e-9 AD=273.6e-15 AS=273.6e-15 PD=1.8e-6 PS=1.8e-6 M=1
m717 n49 n47 0 0 nmos L=240e-9 W=360e-9 AD=273.6e-15 AS=273.6e-15 PD=1.8e-6 PS=1.8e-6 M=1
m718 0 n49 n48 0 nmos L=240e-9 W=360e-9 AD=273.6e-15 AS=158.4e-15 PD=1.8e-6 PS=840e-9 M=1
m719 n48 n46 0 0 nmos L=240e-9 W=360e-9 AD=158.4e-15 AS=273.6e-15 PD=840e-9 PS=1.8e-6 M=1
m720 n46 n43 0 0 nmos L=240e-9 W=360e-9 AD=273.6e-15 AS=273.6e-15 PD=1.8e-6 PS=1.8e-6 M=1
m721 n44 n41 0 0 nmos L=240e-9 W=360e-9 AD=273.6e-15 AS=273.6e-15 PD=1.8e-6 PS=1.8e-6 M=1
m722 n36 n32 0 0 nmos L=240e-9 W=360e-9 AD=273.6e-15 AS=273.6e-15 PD=1.8e-6 PS=1.8e-6 M=1
m723 0 n49 n33 0 nmos L=240e-9 W=360e-9 AD=273.6e-15 AS=158.4e-15 PD=1.8e-6 PS=840e-9 M=1
m724 n33 n29 0 0 nmos L=240e-9 W=360e-9 AD=158.4e-15 AS=273.6e-15 PD=840e-9 PS=1.8e-6 M=1
m725 0 0 n30 0 nmos L=240e-9 W=360e-9 AD=273.6e-15 AS=158.4e-15 PD=1.8e-6 PS=840e-9 M=1
m726 n30 n25 0 0 nmos L=240e-9 W=360e-9 AD=158.4e-15 AS=273.6e-15 PD=840e-9 PS=1.8e-6 M=1
m727 n29 n22 0 0 nmos L=240e-9 W=360e-9 AD=273.6e-15 AS=273.6e-15 PD=1.8e-6 PS=1.8e-6 M=1
m728 n26 n12 0 0 nmos L=240e-9 W=360e-9 AD=273.6e-15 AS=273.6e-15 PD=1.8e-6 PS=1.8e-6 M=1
m729 n27 n13 0 0 nmos L=240e-9 W=360e-9 AD=273.6e-15 AS=273.6e-15 PD=1.8e-6 PS=1.8e-6 M=1
m730 n25 n19 0 0 nmos L=240e-9 W=360e-9 AD=273.6e-15 AS=273.6e-15 PD=1.8e-6 PS=1.8e-6 M=1
m731 n24 n18 0 0 nmos L=240e-9 W=360e-9 AD=273.6e-15 AS=273.6e-15 PD=1.8e-6 PS=1.8e-6 M=1
m732 n23 n17 0 0 nmos L=240e-9 W=360e-9 AD=273.6e-15 AS=273.6e-15 PD=1.8e-6 PS=1.8e-6 M=1
m733 n21 n16 0 0 nmos L=240e-9 W=360e-9 AD=273.6e-15 AS=273.6e-15 PD=1.8e-6 PS=1.8e-6 M=1
m734 n20 n15 0 0 nmos L=240e-9 W=360e-9 AD=273.6e-15 AS=273.6e-15 PD=1.8e-6 PS=1.8e-6 M=1
m735 0 n19 n11 0 nmos L=240e-9 W=360e-9 AD=273.6e-15 AS=273.6e-15 PD=1.8e-6 PS=1.8e-6 M=1
m736 0 n18 n10 0 nmos L=240e-9 W=360e-9 AD=273.6e-15 AS=273.6e-15 PD=1.8e-6 PS=1.8e-6 M=1
m737 0 n17 n9 0 nmos L=240e-9 W=360e-9 AD=273.6e-15 AS=273.6e-15 PD=1.8e-6 PS=1.8e-6 M=1
m738 0 n49 n8 0 nmos L=240e-9 W=360e-9 AD=273.6e-15 AS=158.4e-15 PD=1.8e-6 PS=840e-9 M=1
m739 n8 n28 0 0 nmos L=240e-9 W=360e-9 AD=158.4e-15 AS=273.6e-15 PD=840e-9 PS=1.8e-6 M=1
m740 n28 n56 n97 0 nmos L=240e-9 W=720e-9 AD=237.6e-15 AS=259.2e-15 PD=900e-9 PS=720e-9 M=1
m741 n97 n68 0 0 nmos L=240e-9 W=720e-9 AD=259.2e-15 AS=432e-15 PD=720e-9 PS=1.92e-6 M=1
m742 n67 clk n96 0 nmos L=240e-9 W=720e-9 AD=432e-15 AS=172.8e-15 PD=1.92e-6 PS=480e-9 M=1
m743 n96 n66 0 0 nmos L=240e-9 W=720e-9 AD=172.8e-15 AS=432e-15 PD=480e-9 PS=1.92e-6 M=1
m744 n66 clk n95 0 nmos L=240e-9 W=720e-9 AD=432e-15 AS=172.8e-15 PD=1.92e-6 PS=480e-9 M=1
m745 n95 n62 0 0 nmos L=240e-9 W=720e-9 AD=172.8e-15 AS=432e-15 PD=480e-9 PS=1.92e-6 M=1
m746 n60 clk n94 0 nmos L=240e-9 W=720e-9 AD=432e-15 AS=172.8e-15 PD=1.92e-6 PS=480e-9 M=1
m747 n94 n58 0 0 nmos L=240e-9 W=720e-9 AD=172.8e-15 AS=432e-15 PD=480e-9 PS=1.92e-6 M=1
m748 n58 clk n93 0 nmos L=240e-9 W=720e-9 AD=432e-15 AS=172.8e-15 PD=1.92e-6 PS=480e-9 M=1
m749 n93 n57 0 0 nmos L=240e-9 W=720e-9 AD=172.8e-15 AS=432e-15 PD=480e-9 PS=1.92e-6 M=1
m750 n54 clk n92 0 nmos L=240e-9 W=720e-9 AD=432e-15 AS=172.8e-15 PD=1.92e-6 PS=480e-9 M=1
m751 n92 n51 0 0 nmos L=240e-9 W=720e-9 AD=172.8e-15 AS=432e-15 PD=480e-9 PS=1.92e-6 M=1
m752 n51 clk n91 0 nmos L=240e-9 W=720e-9 AD=432e-15 AS=172.8e-15 PD=1.92e-6 PS=480e-9 M=1
m753 n91 n48 0 0 nmos L=240e-9 W=720e-9 AD=172.8e-15 AS=432e-15 PD=480e-9 PS=1.92e-6 M=1
m754 n47 n44 n90 0 nmos L=240e-9 W=720e-9 AD=432e-15 AS=172.8e-15 PD=1.92e-6 PS=480e-9 M=1
m755 n90 n19 0 0 nmos L=240e-9 W=720e-9 AD=172.8e-15 AS=432e-15 PD=480e-9 PS=1.92e-6 M=1
m756 n43 clk n88 0 nmos L=240e-9 W=720e-9 AD=432e-15 AS=172.8e-15 PD=1.92e-6 PS=480e-9 M=1
m757 n88 n37 0 0 nmos L=240e-9 W=720e-9 AD=172.8e-15 AS=432e-15 PD=480e-9 PS=1.92e-6 M=1
m758 n41 clk n87 0 nmos L=240e-9 W=720e-9 AD=432e-15 AS=172.8e-15 PD=1.92e-6 PS=480e-9 M=1
m759 n40 n24 n86 0 nmos L=240e-9 W=720e-9 AD=432e-15 AS=172.8e-15 PD=1.92e-6 PS=480e-9 M=1
m760 n87 n34 0 0 nmos L=240e-9 W=720e-9 AD=172.8e-15 AS=432e-15 PD=480e-9 PS=1.92e-6 M=1
m761 n86 n17 n28 0 nmos L=240e-9 W=720e-9 AD=172.8e-15 AS=432e-15 PD=480e-9 PS=1.92e-6 M=1
m762 n37 clk n85 0 nmos L=240e-9 W=720e-9 AD=432e-15 AS=172.8e-15 PD=1.92e-6 PS=480e-9 M=1
m763 n85 n33 0 0 nmos L=240e-9 W=720e-9 AD=172.8e-15 AS=432e-15 PD=480e-9 PS=1.92e-6 M=1
m764 n35 n18 n84 0 nmos L=240e-9 W=720e-9 AD=432e-15 AS=172.8e-15 PD=1.92e-6 PS=480e-9 M=1
m765 n34 clk n83 0 nmos L=240e-9 W=720e-9 AD=432e-15 AS=172.8e-15 PD=1.92e-6 PS=480e-9 M=1
m766 n84 n23 n28 0 nmos L=240e-9 W=720e-9 AD=172.8e-15 AS=432e-15 PD=480e-9 PS=1.92e-6 M=1
m767 n83 n30 0 0 nmos L=240e-9 W=720e-9 AD=172.8e-15 AS=432e-15 PD=480e-9 PS=1.92e-6 M=1
m768 n32 n24 n82 0 nmos L=240e-9 W=720e-9 AD=432e-15 AS=172.8e-15 PD=1.92e-6 PS=480e-9 M=1
m769 n82 n23 n28 0 nmos L=240e-9 W=720e-9 AD=172.8e-15 AS=432e-15 PD=480e-9 PS=1.92e-6 M=1
m770 n22 clk n81 0 nmos L=240e-9 W=720e-9 AD=432e-15 AS=172.8e-15 PD=1.92e-6 PS=480e-9 M=1
m771 n81 n14 0 0 nmos L=240e-9 W=720e-9 AD=172.8e-15 AS=432e-15 PD=480e-9 PS=1.92e-6 M=1
m772 n19 n11 0 0 nmos L=240e-9 W=720e-9 AD=432e-15 AS=432e-15 PD=1.92e-6 PS=1.92e-6 M=1
m773 n18 n10 0 0 nmos L=240e-9 W=720e-9 AD=432e-15 AS=432e-15 PD=1.92e-6 PS=1.92e-6 M=1
m774 n17 n9 0 0 nmos L=240e-9 W=720e-9 AD=432e-15 AS=432e-15 PD=1.92e-6 PS=1.92e-6 M=1
m775 n16 n18 n80 0 nmos L=240e-9 W=720e-9 AD=432e-15 AS=172.8e-15 PD=1.92e-6 PS=480e-9 M=1
m776 n15 n18 n79 0 nmos L=240e-9 W=720e-9 AD=432e-15 AS=172.8e-15 PD=1.92e-6 PS=480e-9 M=1
m777 n14 clk n78 0 nmos L=240e-9 W=720e-9 AD=432e-15 AS=172.8e-15 PD=1.92e-6 PS=480e-9 M=1
m778 n80 n17 0 0 nmos L=240e-9 W=720e-9 AD=172.8e-15 AS=432e-15 PD=480e-9 PS=1.92e-6 M=1
m779 n79 n23 0 0 nmos L=240e-9 W=720e-9 AD=172.8e-15 AS=432e-15 PD=480e-9 PS=1.92e-6 M=1
m780 n78 n8 0 0 nmos L=240e-9 W=720e-9 AD=172.8e-15 AS=432e-15 PD=480e-9 PS=1.92e-6 M=1
m781 n13 n24 n77 0 nmos L=240e-9 W=720e-9 AD=432e-15 AS=172.8e-15 PD=1.92e-6 PS=480e-9 M=1
m782 n12 n24 n76 0 nmos L=240e-9 W=720e-9 AD=432e-15 AS=172.8e-15 PD=1.92e-6 PS=480e-9 M=1
m783 n77 n17 0 0 nmos L=240e-9 W=720e-9 AD=172.8e-15 AS=432e-15 PD=480e-9 PS=1.92e-6 M=1
m784 n76 n23 0 0 nmos L=240e-9 W=720e-9 AD=172.8e-15 AS=432e-15 PD=480e-9 PS=1.92e-6 M=1
m785 0 n70 n71 0 nmos L=240e-9 W=900e-9 AD=540e-15 AS=324e-15 PD=2.1e-6 PS=720e-9 M=1
m786 n71 n70 0 0 nmos L=240e-9 W=900e-9 AD=324e-15 AS=540e-15 PD=720e-9 PS=2.1e-6 M=1
m787 n59 n21 d 0 nmos L=240e-9 W=6.24e-6 AD=3.744e-12 AS=2.2464e-12 PD=7.44e-6 PS=720e-9 M=1
m788 d n21 n59 0 nmos L=240e-9 W=6.24e-6 AD=2.2464e-12 AS=2.2464e-12 PD=720e-9 PS=720e-9 M=1
m789 n59 n21 d 0 nmos L=240e-9 W=6.24e-6 AD=2.2464e-12 AS=2.2464e-12 PD=720e-9 PS=720e-9 M=1
m790 d n21 n59 0 nmos L=240e-9 W=6.24e-6 AD=2.2464e-12 AS=2.2464e-12 PD=720e-9 PS=720e-9 M=1
m791 n59 n21 d 0 nmos L=240e-9 W=6.24e-6 AD=2.2464e-12 AS=2.2464e-12 PD=720e-9 PS=720e-9 M=1
m792 d n21 n59 0 nmos L=240e-9 W=6.24e-6 AD=2.2464e-12 AS=2.2464e-12 PD=720e-9 PS=720e-9 M=1
m793 n59 n21 d 0 nmos L=240e-9 W=6.24e-6 AD=2.2464e-12 AS=2.2464e-12 PD=720e-9 PS=720e-9 M=1
m794 d n21 n59 0 nmos L=240e-9 W=6.24e-6 AD=2.2464e-12 AS=2.2464e-12 PD=720e-9 PS=720e-9 M=1
m795 n59 n21 d 0 nmos L=240e-9 W=6.24e-6 AD=2.2464e-12 AS=2.2464e-12 PD=720e-9 PS=720e-9 M=1
m796 d n21 n59 0 nmos L=240e-9 W=6.24e-6 AD=2.2464e-12 AS=2.2464e-12 PD=720e-9 PS=720e-9 M=1
m797 n59 n21 d 0 nmos L=240e-9 W=6.24e-6 AD=2.2464e-12 AS=2.2464e-12 PD=720e-9 PS=720e-9 M=1
m798 d n21 n59 0 nmos L=240e-9 W=6.24e-6 AD=2.2464e-12 AS=2.2464e-12 PD=720e-9 PS=720e-9 M=1
m799 n59 n21 d 0 nmos L=240e-9 W=6.24e-6 AD=2.2464e-12 AS=2.2464e-12 PD=720e-9 PS=720e-9 M=1
m800 d n21 n59 0 nmos L=240e-9 W=6.24e-6 AD=2.2464e-12 AS=2.2464e-12 PD=720e-9 PS=720e-9 M=1
m801 n59 n21 d 0 nmos L=240e-9 W=6.24e-6 AD=2.2464e-12 AS=2.2464e-12 PD=720e-9 PS=720e-9 M=1
m802 d n21 n59 0 nmos L=240e-9 W=6.24e-6 AD=2.2464e-12 AS=3.744e-12 PD=720e-9 PS=7.44e-6 M=1
m803 0 n63 n65 0 nmos L=240e-9 W=7.62e-6 AD=4.572e-12 AS=2.7432e-12 PD=8.82e-6 PS=720e-9 M=1
m804 n65 n63 0 0 nmos L=240e-9 W=7.62e-6 AD=2.7432e-12 AS=4.572e-12 PD=720e-9 PS=8.82e-6 M=1
m805 n63 n64 0 0 nmos L=240e-9 W=2.34e-6 AD=1.404e-12 AS=1.404e-12 PD=3.54e-6 PS=3.54e-6 M=1
m806 0 n55 n50 0 nmos L=240e-9 W=7.8e-6 AD=4.68e-12 AS=2.808e-12 PD=9e-6 PS=720e-9 M=1
m807 n50 n55 0 0 nmos L=240e-9 W=7.8e-6 AD=2.808e-12 AS=2.808e-12 PD=720e-9 PS=720e-9 M=1
m808 0 n55 n50 0 nmos L=240e-9 W=7.8e-6 AD=2.808e-12 AS=2.808e-12 PD=720e-9 PS=720e-9 M=1
m809 n50 n55 0 0 nmos L=240e-9 W=7.8e-6 AD=2.808e-12 AS=2.808e-12 PD=720e-9 PS=720e-9 M=1
m810 0 n55 n50 0 nmos L=240e-9 W=7.8e-6 AD=2.808e-12 AS=2.808e-12 PD=720e-9 PS=720e-9 M=1
m811 n50 n55 0 0 nmos L=240e-9 W=7.8e-6 AD=2.808e-12 AS=2.808e-12 PD=720e-9 PS=720e-9 M=1
m812 0 n55 n50 0 nmos L=240e-9 W=7.8e-6 AD=2.808e-12 AS=2.808e-12 PD=720e-9 PS=720e-9 M=1
m813 n50 n55 0 0 nmos L=240e-9 W=7.8e-6 AD=2.808e-12 AS=2.808e-12 PD=720e-9 PS=720e-9 M=1
m814 0 n55 n50 0 nmos L=240e-9 W=7.8e-6 AD=2.808e-12 AS=2.808e-12 PD=720e-9 PS=720e-9 M=1
m815 n50 n55 0 0 nmos L=240e-9 W=7.8e-6 AD=2.808e-12 AS=4.68e-12 PD=720e-9 PS=9e-6 M=1
m816 n50 n27 d 0 nmos L=240e-9 W=6.48e-6 AD=3.888e-12 AS=2.3328e-12 PD=7.68e-6 PS=720e-9 M=1
m817 d n27 n50 0 nmos L=240e-9 W=6.48e-6 AD=2.3328e-12 AS=2.3328e-12 PD=720e-9 PS=720e-9 M=1
m818 n50 n27 d 0 nmos L=240e-9 W=6.48e-6 AD=2.3328e-12 AS=2.3328e-12 PD=720e-9 PS=720e-9 M=1
m819 d n27 n50 0 nmos L=240e-9 W=6.48e-6 AD=2.3328e-12 AS=2.3328e-12 PD=720e-9 PS=720e-9 M=1
m820 n50 n27 d 0 nmos L=240e-9 W=6.48e-6 AD=2.3328e-12 AS=2.3328e-12 PD=720e-9 PS=720e-9 M=1
m821 0 n53 n55 0 nmos L=240e-9 W=6.48e-6 AD=3.888e-12 AS=2.3328e-12 PD=7.68e-6 PS=720e-9 M=1
m822 d n27 n50 0 nmos L=240e-9 W=6.48e-6 AD=2.3328e-12 AS=2.3328e-12 PD=720e-9 PS=720e-9 M=1
m823 n55 n53 0 0 nmos L=240e-9 W=6.48e-6 AD=2.3328e-12 AS=3.888e-12 PD=720e-9 PS=7.68e-6 M=1
m824 n50 n27 d 0 nmos L=240e-9 W=6.48e-6 AD=2.3328e-12 AS=2.3328e-12 PD=720e-9 PS=720e-9 M=1
m825 d n27 n50 0 nmos L=240e-9 W=6.48e-6 AD=2.3328e-12 AS=2.3328e-12 PD=720e-9 PS=720e-9 M=1
m826 n50 n27 d 0 nmos L=240e-9 W=6.48e-6 AD=2.3328e-12 AS=2.3328e-12 PD=720e-9 PS=720e-9 M=1
m827 d n27 n50 0 nmos L=240e-9 W=6.48e-6 AD=2.3328e-12 AS=2.3328e-12 PD=720e-9 PS=720e-9 M=1
m828 n50 n27 d 0 nmos L=240e-9 W=6.48e-6 AD=2.3328e-12 AS=2.3328e-12 PD=720e-9 PS=720e-9 M=1
m829 d n27 n50 0 nmos L=240e-9 W=6.48e-6 AD=2.3328e-12 AS=3.888e-12 PD=720e-9 PS=7.68e-6 M=1
m830 n53 n52 0 0 nmos L=240e-9 W=2.16e-6 AD=1.296e-12 AS=1.296e-12 PD=3.36e-6 PS=3.36e-6 M=1
m831 n31 n42 0 0 nmos L=240e-9 W=2.22e-6 AD=1.332e-12 AS=799.2e-15 PD=3.42e-6 PS=720e-9 M=1
m832 0 n42 n31 0 nmos L=240e-9 W=2.22e-6 AD=799.2e-15 AS=799.2e-15 PD=720e-9 PS=720e-9 M=1
m833 n31 n42 0 0 nmos L=240e-9 W=2.22e-6 AD=799.2e-15 AS=799.2e-15 PD=720e-9 PS=720e-9 M=1
m834 0 n42 n31 0 nmos L=240e-9 W=2.22e-6 AD=799.2e-15 AS=799.2e-15 PD=720e-9 PS=720e-9 M=1
m835 n31 n42 0 0 nmos L=240e-9 W=2.22e-6 AD=799.2e-15 AS=799.2e-15 PD=720e-9 PS=720e-9 M=1
m836 0 n42 n31 0 nmos L=240e-9 W=2.22e-6 AD=799.2e-15 AS=799.2e-15 PD=720e-9 PS=720e-9 M=1
m837 n31 n42 0 0 nmos L=240e-9 W=2.22e-6 AD=799.2e-15 AS=1.332e-12 PD=720e-9 PS=3.42e-6 M=1
m838 0 n39 n42 0 nmos L=240e-9 W=2.22e-6 AD=1.332e-12 AS=799.2e-15 PD=3.42e-6 PS=720e-9 M=1
m839 n42 n39 0 0 nmos L=240e-9 W=2.22e-6 AD=799.2e-15 AS=1.332e-12 PD=720e-9 PS=3.42e-6 M=1
m840 n38 n20 d 0 nmos L=240e-9 W=5.64e-6 AD=3.384e-12 AS=2.0304e-12 PD=6.84e-6 PS=720e-9 M=1
m841 d n20 n38 0 nmos L=240e-9 W=5.64e-6 AD=2.0304e-12 AS=2.0304e-12 PD=720e-9 PS=720e-9 M=1
m842 n38 n20 d 0 nmos L=240e-9 W=5.64e-6 AD=2.0304e-12 AS=2.0304e-12 PD=720e-9 PS=720e-9 M=1
m843 d n20 n38 0 nmos L=240e-9 W=5.64e-6 AD=2.0304e-12 AS=2.0304e-12 PD=720e-9 PS=720e-9 M=1
m844 n38 n20 d 0 nmos L=240e-9 W=5.64e-6 AD=2.0304e-12 AS=2.0304e-12 PD=720e-9 PS=720e-9 M=1
m845 d n20 n38 0 nmos L=240e-9 W=5.64e-6 AD=2.0304e-12 AS=2.0304e-12 PD=720e-9 PS=720e-9 M=1
m846 n38 n20 d 0 nmos L=240e-9 W=5.64e-6 AD=2.0304e-12 AS=2.0304e-12 PD=720e-9 PS=720e-9 M=1
m847 d n20 n38 0 nmos L=240e-9 W=5.64e-6 AD=2.0304e-12 AS=3.384e-12 PD=720e-9 PS=6.84e-6 M=1
m848 n45 n18 n89 0 nmos L=240e-9 W=2.88e-6 AD=1.728e-12 AS=691.2e-15 PD=4.08e-6 PS=480e-9 M=1
m849 n89 n17 n28 0 nmos L=240e-9 W=2.88e-6 AD=691.2e-15 AS=1.728e-12 PD=480e-9 PS=4.08e-6 M=1
m850 n39 n36 0 0 nmos L=240e-9 W=1.26e-6 AD=756e-15 AS=756e-15 PD=2.46e-6 PS=2.46e-6 M=1
m851 n31 n26 d 0 nmos L=240e-9 W=3.84e-6 AD=2.304e-12 AS=1.3824e-12 PD=5.04e-6 PS=720e-9 M=1
m852 d n26 n31 0 nmos L=240e-9 W=3.84e-6 AD=1.3824e-12 AS=1.3824e-12 PD=720e-9 PS=720e-9 M=1
m853 n31 n26 d 0 nmos L=240e-9 W=3.84e-6 AD=1.3824e-12 AS=1.3824e-12 PD=720e-9 PS=720e-9 M=1
m854 d n26 n31 0 nmos L=240e-9 W=3.84e-6 AD=1.3824e-12 AS=2.304e-12 PD=720e-9 PS=5.04e-6 M=1
m855 n11 rst 0 0 nmos L=240e-9 W=540e-9 AD=324e-15 AS=324e-15 PD=1.74e-6 PS=1.74e-6 M=1
m856 n10 c2 0 0 nmos L=240e-9 W=540e-9 AD=324e-15 AS=324e-15 PD=1.74e-6 PS=1.74e-6 M=1
m857 n9 c1 0 0 nmos L=240e-9 W=540e-9 AD=324e-15 AS=324e-15 PD=1.74e-6 PS=1.74e-6 M=1
m858 vdd! n65 n59 vdd! pmos L=240e-9 W=14.1e-6 AD=8.46e-12 AS=5.076e-12 PD=15.3e-6 PS=720e-9 M=1
m859 n59 n65 vdd! vdd! pmos L=240e-9 W=14.1e-6 AD=5.076e-12 AS=5.076e-12 PD=720e-9 PS=720e-9 M=1
m860 vdd! n65 n59 vdd! pmos L=240e-9 W=14.1e-6 AD=5.076e-12 AS=5.076e-12 PD=720e-9 PS=720e-9 M=1
m861 n59 n65 vdd! vdd! pmos L=240e-9 W=14.1e-6 AD=5.076e-12 AS=5.076e-12 PD=720e-9 PS=720e-9 M=1
m862 vdd! n65 n59 vdd! pmos L=240e-9 W=14.1e-6 AD=5.076e-12 AS=5.076e-12 PD=720e-9 PS=720e-9 M=1
m863 n59 n65 vdd! vdd! pmos L=240e-9 W=14.1e-6 AD=5.076e-12 AS=5.076e-12 PD=720e-9 PS=720e-9 M=1
m864 vdd! n65 n59 vdd! pmos L=240e-9 W=14.1e-6 AD=5.076e-12 AS=5.076e-12 PD=720e-9 PS=720e-9 M=1
m865 n59 n65 vdd! vdd! pmos L=240e-9 W=14.1e-6 AD=5.076e-12 AS=5.076e-12 PD=720e-9 PS=720e-9 M=1
m866 vdd! n65 n59 vdd! pmos L=240e-9 W=14.1e-6 AD=5.076e-12 AS=5.076e-12 PD=720e-9 PS=720e-9 M=1
m867 n59 n65 vdd! vdd! pmos L=240e-9 W=14.1e-6 AD=5.076e-12 AS=5.076e-12 PD=720e-9 PS=720e-9 M=1
m868 vdd! n65 n59 vdd! pmos L=240e-9 W=14.1e-6 AD=5.076e-12 AS=5.076e-12 PD=720e-9 PS=720e-9 M=1
m869 n59 n65 vdd! vdd! pmos L=240e-9 W=14.1e-6 AD=5.076e-12 AS=5.076e-12 PD=720e-9 PS=720e-9 M=1
m870 vdd! n65 n59 vdd! pmos L=240e-9 W=14.1e-6 AD=5.076e-12 AS=5.076e-12 PD=720e-9 PS=720e-9 M=1
m871 n59 n65 vdd! vdd! pmos L=240e-9 W=14.1e-6 AD=5.076e-12 AS=8.46e-12 PD=720e-9 PS=15.3e-6 M=1
m872 vdd! n69 n73 vdd! pmos L=240e-9 W=1.44e-6 AD=864e-15 AS=518.4e-15 PD=2.64e-6 PS=720e-9 M=1
m873 n73 n56 n28 vdd! pmos L=240e-9 W=1.44e-6 AD=518.4e-15 AS=518.4e-15 PD=720e-9 PS=720e-9 M=1
m874 n28 n68 n73 vdd! pmos L=240e-9 W=1.44e-6 AD=518.4e-15 AS=864e-15 PD=720e-9 PS=2.64e-6 M=1
m875 n69 n56 n110 vdd! pmos L=240e-9 W=1.44e-6 AD=864e-15 AS=518.4e-15 PD=2.64e-6 PS=720e-9 M=1
m876 n110 n68 vdd! vdd! pmos L=240e-9 W=1.44e-6 AD=518.4e-15 AS=864e-15 PD=720e-9 PS=2.64e-6 M=1
m877 n19 n11 vdd! vdd! pmos L=240e-9 W=1.44e-6 AD=864e-15 AS=864e-15 PD=2.64e-6 PS=2.64e-6 M=1
m878 n18 n10 vdd! vdd! pmos L=240e-9 W=1.44e-6 AD=864e-15 AS=864e-15 PD=2.64e-6 PS=2.64e-6 M=1
m879 n17 n9 vdd! vdd! pmos L=240e-9 W=1.44e-6 AD=864e-15 AS=864e-15 PD=2.64e-6 PS=2.64e-6 M=1
m880 vdd! n70 n71 vdd! pmos L=240e-9 W=1.8e-6 AD=1.08e-12 AS=648e-15 PD=3e-6 PS=720e-9 M=1
m881 n71 n70 vdd! vdd! pmos L=240e-9 W=1.8e-6 AD=648e-15 AS=1.08e-12 PD=720e-9 PS=3e-6 M=1
m882 n70 n35 vdd! vdd! pmos L=240e-9 W=720e-9 AD=432e-15 AS=432e-15 PD=1.92e-6 PS=1.92e-6 M=1
m883 n68 n67 vdd! vdd! pmos L=240e-9 W=720e-9 AD=432e-15 AS=432e-15 PD=1.92e-6 PS=1.92e-6 M=1
m884 n67 n66 vdd! vdd! pmos L=240e-9 W=720e-9 AD=432e-15 AS=432e-15 PD=1.92e-6 PS=1.92e-6 M=1
m885 n66 clk vdd! vdd! pmos L=240e-9 W=720e-9 AD=432e-15 AS=432e-15 PD=1.92e-6 PS=1.92e-6 M=1
m886 n64 n45 vdd! vdd! pmos L=240e-9 W=720e-9 AD=432e-15 AS=432e-15 PD=1.92e-6 PS=1.92e-6 M=1
m887 n61 n60 vdd! vdd! pmos L=240e-9 W=720e-9 AD=432e-15 AS=432e-15 PD=1.92e-6 PS=1.92e-6 M=1
m888 n60 n58 vdd! vdd! pmos L=240e-9 W=720e-9 AD=432e-15 AS=432e-15 PD=1.92e-6 PS=1.92e-6 M=1
m889 n58 clk vdd! vdd! pmos L=240e-9 W=720e-9 AD=432e-15 AS=432e-15 PD=1.92e-6 PS=1.92e-6 M=1
m890 n56 n54 vdd! vdd! pmos L=240e-9 W=720e-9 AD=432e-15 AS=432e-15 PD=1.92e-6 PS=1.92e-6 M=1
m891 n54 n51 vdd! vdd! pmos L=240e-9 W=720e-9 AD=432e-15 AS=432e-15 PD=1.92e-6 PS=1.92e-6 M=1
m892 n52 n40 vdd! vdd! pmos L=240e-9 W=720e-9 AD=432e-15 AS=432e-15 PD=1.92e-6 PS=1.92e-6 M=1
m893 n51 clk vdd! vdd! pmos L=240e-9 W=720e-9 AD=432e-15 AS=432e-15 PD=1.92e-6 PS=1.92e-6 M=1
m894 n49 n47 vdd! vdd! pmos L=240e-9 W=720e-9 AD=432e-15 AS=432e-15 PD=1.92e-6 PS=1.92e-6 M=1
m895 vdd! n44 n47 vdd! pmos L=240e-9 W=720e-9 AD=432e-15 AS=259.2e-15 PD=1.92e-6 PS=720e-9 M=1
m896 n47 n19 vdd! vdd! pmos L=240e-9 W=720e-9 AD=259.2e-15 AS=432e-15 PD=720e-9 PS=1.92e-6 M=1
m897 n46 n43 vdd! vdd! pmos L=240e-9 W=720e-9 AD=432e-15 AS=432e-15 PD=1.92e-6 PS=1.92e-6 M=1
m898 n44 n41 vdd! vdd! pmos L=240e-9 W=720e-9 AD=432e-15 AS=432e-15 PD=1.92e-6 PS=1.92e-6 M=1
m899 n43 n37 vdd! vdd! pmos L=240e-9 W=720e-9 AD=432e-15 AS=432e-15 PD=1.92e-6 PS=1.92e-6 M=1
m900 n41 n34 vdd! vdd! pmos L=240e-9 W=720e-9 AD=432e-15 AS=432e-15 PD=1.92e-6 PS=1.92e-6 M=1
m901 n37 clk vdd! vdd! pmos L=240e-9 W=720e-9 AD=432e-15 AS=432e-15 PD=1.92e-6 PS=1.92e-6 M=1
m902 n36 n32 vdd! vdd! pmos L=240e-9 W=720e-9 AD=432e-15 AS=432e-15 PD=1.92e-6 PS=1.92e-6 M=1
m903 n34 clk vdd! vdd! pmos L=240e-9 W=720e-9 AD=432e-15 AS=432e-15 PD=1.92e-6 PS=1.92e-6 M=1
m904 n29 n22 vdd! vdd! pmos L=240e-9 W=720e-9 AD=432e-15 AS=432e-15 PD=1.92e-6 PS=1.92e-6 M=1
m905 n27 n13 vdd! vdd! pmos L=240e-9 W=720e-9 AD=432e-15 AS=432e-15 PD=1.92e-6 PS=1.92e-6 M=1
m906 n26 n12 vdd! vdd! pmos L=240e-9 W=720e-9 AD=432e-15 AS=432e-15 PD=1.92e-6 PS=1.92e-6 M=1
m907 n23 n17 vdd! vdd! pmos L=240e-9 W=720e-9 AD=432e-15 AS=432e-15 PD=1.92e-6 PS=1.92e-6 M=1
m908 n25 n19 vdd! vdd! pmos L=240e-9 W=720e-9 AD=432e-15 AS=432e-15 PD=1.92e-6 PS=1.92e-6 M=1
m909 n24 n18 vdd! vdd! pmos L=240e-9 W=720e-9 AD=432e-15 AS=432e-15 PD=1.92e-6 PS=1.92e-6 M=1
m910 n21 n16 vdd! vdd! pmos L=240e-9 W=720e-9 AD=432e-15 AS=432e-15 PD=1.92e-6 PS=1.92e-6 M=1
m911 n20 n15 vdd! vdd! pmos L=240e-9 W=720e-9 AD=432e-15 AS=432e-15 PD=1.92e-6 PS=1.92e-6 M=1
m912 n22 n14 vdd! vdd! pmos L=240e-9 W=720e-9 AD=432e-15 AS=432e-15 PD=1.92e-6 PS=1.92e-6 M=1
m913 vdd! n18 n16 vdd! pmos L=240e-9 W=720e-9 AD=432e-15 AS=259.2e-15 PD=1.92e-6 PS=720e-9 M=1
m914 vdd! n18 n15 vdd! pmos L=240e-9 W=720e-9 AD=432e-15 AS=259.2e-15 PD=1.92e-6 PS=720e-9 M=1
m915 n14 clk vdd! vdd! pmos L=240e-9 W=720e-9 AD=432e-15 AS=432e-15 PD=1.92e-6 PS=1.92e-6 M=1
m916 n15 n23 vdd! vdd! pmos L=240e-9 W=720e-9 AD=259.2e-15 AS=432e-15 PD=720e-9 PS=1.92e-6 M=1
m917 n16 n17 vdd! vdd! pmos L=240e-9 W=720e-9 AD=259.2e-15 AS=432e-15 PD=720e-9 PS=1.92e-6 M=1
m918 vdd! n19 n11 vdd! pmos L=240e-9 W=720e-9 AD=432e-15 AS=432e-15 PD=1.92e-6 PS=1.92e-6 M=1
m919 vdd! n18 n10 vdd! pmos L=240e-9 W=720e-9 AD=432e-15 AS=432e-15 PD=1.92e-6 PS=1.92e-6 M=1
m920 vdd! n17 n9 vdd! pmos L=240e-9 W=720e-9 AD=432e-15 AS=432e-15 PD=1.92e-6 PS=1.92e-6 M=1
m921 vdd! n24 n13 vdd! pmos L=240e-9 W=720e-9 AD=432e-15 AS=259.2e-15 PD=1.92e-6 PS=720e-9 M=1
m922 vdd! n24 n12 vdd! pmos L=240e-9 W=720e-9 AD=432e-15 AS=259.2e-15 PD=1.92e-6 PS=720e-9 M=1
m923 n13 n17 vdd! vdd! pmos L=240e-9 W=720e-9 AD=259.2e-15 AS=432e-15 PD=720e-9 PS=1.92e-6 M=1
m924 n12 n23 vdd! vdd! pmos L=240e-9 W=720e-9 AD=259.2e-15 AS=432e-15 PD=720e-9 PS=1.92e-6 M=1
m925 n59 n16 d vdd! pmos L=240e-9 W=6.18e-6 AD=3.708e-12 AS=2.2248e-12 PD=7.38e-6 PS=720e-9 M=1
m926 d n16 n59 vdd! pmos L=240e-9 W=6.18e-6 AD=2.2248e-12 AS=2.2248e-12 PD=720e-9 PS=720e-9 M=1
m927 n59 n16 d vdd! pmos L=240e-9 W=6.18e-6 AD=2.2248e-12 AS=2.2248e-12 PD=720e-9 PS=720e-9 M=1
m928 d n16 n59 vdd! pmos L=240e-9 W=6.18e-6 AD=2.2248e-12 AS=2.2248e-12 PD=720e-9 PS=720e-9 M=1
m929 n59 n16 d vdd! pmos L=240e-9 W=6.18e-6 AD=2.2248e-12 AS=2.2248e-12 PD=720e-9 PS=720e-9 M=1
m930 d n16 n59 vdd! pmos L=240e-9 W=6.18e-6 AD=2.2248e-12 AS=2.2248e-12 PD=720e-9 PS=720e-9 M=1
m931 n59 n16 d vdd! pmos L=240e-9 W=6.18e-6 AD=2.2248e-12 AS=2.2248e-12 PD=720e-9 PS=720e-9 M=1
m932 d n16 n59 vdd! pmos L=240e-9 W=6.18e-6 AD=2.2248e-12 AS=2.2248e-12 PD=720e-9 PS=720e-9 M=1
m933 n59 n16 d vdd! pmos L=240e-9 W=6.18e-6 AD=2.2248e-12 AS=2.2248e-12 PD=720e-9 PS=720e-9 M=1
m934 d n16 n59 vdd! pmos L=240e-9 W=6.18e-6 AD=2.2248e-12 AS=2.2248e-12 PD=720e-9 PS=720e-9 M=1
m935 n59 n16 d vdd! pmos L=240e-9 W=6.18e-6 AD=2.2248e-12 AS=2.2248e-12 PD=720e-9 PS=720e-9 M=1
m936 d n16 n59 vdd! pmos L=240e-9 W=6.18e-6 AD=2.2248e-12 AS=2.2248e-12 PD=720e-9 PS=720e-9 M=1
m937 n59 n16 d vdd! pmos L=240e-9 W=6.18e-6 AD=2.2248e-12 AS=2.2248e-12 PD=720e-9 PS=720e-9 M=1
m938 d n16 n59 vdd! pmos L=240e-9 W=6.18e-6 AD=2.2248e-12 AS=2.2248e-12 PD=720e-9 PS=720e-9 M=1
m939 n59 n16 d vdd! pmos L=240e-9 W=6.18e-6 AD=2.2248e-12 AS=2.2248e-12 PD=720e-9 PS=720e-9 M=1
m940 d n16 n59 vdd! pmos L=240e-9 W=6.18e-6 AD=2.2248e-12 AS=3.708e-12 PD=720e-9 PS=7.38e-6 M=1
m941 vdd! n63 n65 vdd! pmos L=240e-9 W=15.24e-6 AD=9.144e-12 AS=5.4864e-12 PD=16.44e-6 PS=720e-9 M=1
m942 n65 n63 vdd! vdd! pmos L=240e-9 W=15.24e-6 AD=5.4864e-12 AS=9.144e-12 PD=720e-9 PS=16.44e-6 M=1
m943 n62 clk n109 vdd! pmos L=240e-9 W=2.16e-6 AD=1.296e-12 AS=518.4e-15 PD=3.36e-6 PS=480e-9 M=1
m944 n109 n49 n108 vdd! pmos L=240e-9 W=2.16e-6 AD=518.4e-15 AS=518.4e-15 PD=480e-9 PS=480e-9 M=1
m945 n108 n61 vdd! vdd! pmos L=240e-9 W=2.16e-6 AD=518.4e-15 AS=1.296e-12 PD=480e-9 PS=3.36e-6 M=1
m946 n57 clk n107 vdd! pmos L=240e-9 W=2.16e-6 AD=1.296e-12 AS=518.4e-15 PD=3.36e-6 PS=480e-9 M=1
m947 n107 n49 n106 vdd! pmos L=240e-9 W=2.16e-6 AD=518.4e-15 AS=518.4e-15 PD=480e-9 PS=480e-9 M=1
m948 n106 n56 vdd! vdd! pmos L=240e-9 W=2.16e-6 AD=518.4e-15 AS=1.296e-12 PD=480e-9 PS=3.36e-6 M=1
m949 n48 clk n105 vdd! pmos L=240e-9 W=2.16e-6 AD=1.296e-12 AS=518.4e-15 PD=3.36e-6 PS=480e-9 M=1
m950 n105 n49 n104 vdd! pmos L=240e-9 W=2.16e-6 AD=518.4e-15 AS=518.4e-15 PD=480e-9 PS=480e-9 M=1
m951 n104 n46 vdd! vdd! pmos L=240e-9 W=2.16e-6 AD=518.4e-15 AS=1.296e-12 PD=480e-9 PS=3.36e-6 M=1
m952 n33 clk n103 vdd! pmos L=240e-9 W=2.16e-6 AD=1.296e-12 AS=518.4e-15 PD=3.36e-6 PS=480e-9 M=1
m953 n103 n49 n102 vdd! pmos L=240e-9 W=2.16e-6 AD=518.4e-15 AS=518.4e-15 PD=480e-9 PS=480e-9 M=1
m954 n102 n29 vdd! vdd! pmos L=240e-9 W=2.16e-6 AD=518.4e-15 AS=1.296e-12 PD=480e-9 PS=3.36e-6 M=1
m955 n30 clk n101 vdd! pmos L=240e-9 W=2.16e-6 AD=1.296e-12 AS=518.4e-15 PD=3.36e-6 PS=480e-9 M=1
m956 n101 0 n100 vdd! pmos L=240e-9 W=2.16e-6 AD=518.4e-15 AS=518.4e-15 PD=480e-9 PS=480e-9 M=1
m957 n100 n25 vdd! vdd! pmos L=240e-9 W=2.16e-6 AD=518.4e-15 AS=1.296e-12 PD=480e-9 PS=3.36e-6 M=1
m958 n8 clk n99 vdd! pmos L=240e-9 W=2.16e-6 AD=1.296e-12 AS=518.4e-15 PD=3.36e-6 PS=480e-9 M=1
m959 n99 n49 n98 vdd! pmos L=240e-9 W=2.16e-6 AD=518.4e-15 AS=518.4e-15 PD=480e-9 PS=480e-9 M=1
m960 n98 n28 vdd! vdd! pmos L=240e-9 W=2.16e-6 AD=518.4e-15 AS=1.296e-12 PD=480e-9 PS=3.36e-6 M=1
m961 n63 n64 vdd! vdd! pmos L=240e-9 W=4.68e-6 AD=2.808e-12 AS=2.808e-12 PD=5.88e-6 PS=5.88e-6 M=1
m962 vdd! n55 n50 vdd! pmos L=240e-9 W=15.54e-6 AD=9.324e-12 AS=5.5944e-12 PD=16.74e-6 PS=720e-9 M=1
m963 n50 n55 vdd! vdd! pmos L=240e-9 W=15.54e-6 AD=5.5944e-12 AS=5.5944e-12 PD=720e-9 PS=720e-9 M=1
m964 vdd! n55 n50 vdd! pmos L=240e-9 W=15.54e-6 AD=5.5944e-12 AS=5.5944e-12 PD=720e-9 PS=720e-9 M=1
m965 n50 n55 vdd! vdd! pmos L=240e-9 W=15.54e-6 AD=5.5944e-12 AS=5.5944e-12 PD=720e-9 PS=720e-9 M=1
m966 vdd! n55 n50 vdd! pmos L=240e-9 W=15.54e-6 AD=5.5944e-12 AS=5.5944e-12 PD=720e-9 PS=720e-9 M=1
m967 n50 n55 vdd! vdd! pmos L=240e-9 W=15.54e-6 AD=5.5944e-12 AS=5.5944e-12 PD=720e-9 PS=720e-9 M=1
m968 vdd! n55 n50 vdd! pmos L=240e-9 W=15.54e-6 AD=5.5944e-12 AS=5.5944e-12 PD=720e-9 PS=720e-9 M=1
m969 n50 n55 vdd! vdd! pmos L=240e-9 W=15.54e-6 AD=5.5944e-12 AS=5.5944e-12 PD=720e-9 PS=720e-9 M=1
m970 vdd! n55 n50 vdd! pmos L=240e-9 W=15.54e-6 AD=5.5944e-12 AS=5.5944e-12 PD=720e-9 PS=720e-9 M=1
m971 n50 n55 vdd! vdd! pmos L=240e-9 W=15.54e-6 AD=5.5944e-12 AS=9.324e-12 PD=720e-9 PS=16.74e-6 M=1
m972 n50 n13 d vdd! pmos L=240e-9 W=6.48e-6 AD=3.888e-12 AS=2.3328e-12 PD=7.68e-6 PS=720e-9 M=1
m973 d n13 n50 vdd! pmos L=240e-9 W=6.48e-6 AD=2.3328e-12 AS=2.3328e-12 PD=720e-9 PS=720e-9 M=1
m974 n50 n13 d vdd! pmos L=240e-9 W=6.48e-6 AD=2.3328e-12 AS=2.3328e-12 PD=720e-9 PS=720e-9 M=1
m975 d n13 n50 vdd! pmos L=240e-9 W=6.48e-6 AD=2.3328e-12 AS=2.3328e-12 PD=720e-9 PS=720e-9 M=1
m976 n50 n13 d vdd! pmos L=240e-9 W=6.48e-6 AD=2.3328e-12 AS=2.3328e-12 PD=720e-9 PS=720e-9 M=1
m977 d n13 n50 vdd! pmos L=240e-9 W=6.48e-6 AD=2.3328e-12 AS=2.3328e-12 PD=720e-9 PS=720e-9 M=1
m978 n50 n13 d vdd! pmos L=240e-9 W=6.48e-6 AD=2.3328e-12 AS=2.3328e-12 PD=720e-9 PS=720e-9 M=1
m979 d n13 n50 vdd! pmos L=240e-9 W=6.48e-6 AD=2.3328e-12 AS=2.3328e-12 PD=720e-9 PS=720e-9 M=1
m980 n50 n13 d vdd! pmos L=240e-9 W=6.48e-6 AD=2.3328e-12 AS=2.3328e-12 PD=720e-9 PS=720e-9 M=1
m981 d n13 n50 vdd! pmos L=240e-9 W=6.48e-6 AD=2.3328e-12 AS=2.3328e-12 PD=720e-9 PS=720e-9 M=1
m982 n50 n13 d vdd! pmos L=240e-9 W=6.48e-6 AD=2.3328e-12 AS=2.3328e-12 PD=720e-9 PS=720e-9 M=1
m983 d n13 n50 vdd! pmos L=240e-9 W=6.48e-6 AD=2.3328e-12 AS=3.888e-12 PD=720e-9 PS=7.68e-6 M=1
m984 vdd! n53 n55 vdd! pmos L=240e-9 W=12.96e-6 AD=7.776e-12 AS=4.6656e-12 PD=14.16e-6 PS=720e-9 M=1
m985 n55 n53 vdd! vdd! pmos L=240e-9 W=12.96e-6 AD=4.6656e-12 AS=7.776e-12 PD=720e-9 PS=14.16e-6 M=1
m986 n53 n52 vdd! vdd! pmos L=240e-9 W=4.32e-6 AD=2.592e-12 AS=2.592e-12 PD=5.52e-6 PS=5.52e-6 M=1
m987 n31 n42 vdd! vdd! pmos L=240e-9 W=4.44e-6 AD=2.664e-12 AS=1.5984e-12 PD=5.64e-6 PS=720e-9 M=1
m988 vdd! n42 n31 vdd! pmos L=240e-9 W=4.44e-6 AD=1.5984e-12 AS=1.5984e-12 PD=720e-9 PS=720e-9 M=1
m989 n31 n42 vdd! vdd! pmos L=240e-9 W=4.44e-6 AD=1.5984e-12 AS=1.5984e-12 PD=720e-9 PS=720e-9 M=1
m990 vdd! n42 n31 vdd! pmos L=240e-9 W=4.44e-6 AD=1.5984e-12 AS=1.5984e-12 PD=720e-9 PS=720e-9 M=1
m991 n31 n42 vdd! vdd! pmos L=240e-9 W=4.44e-6 AD=1.5984e-12 AS=1.5984e-12 PD=720e-9 PS=720e-9 M=1
m992 vdd! n42 n31 vdd! pmos L=240e-9 W=4.44e-6 AD=1.5984e-12 AS=1.5984e-12 PD=720e-9 PS=720e-9 M=1
m993 n31 n42 vdd! vdd! pmos L=240e-9 W=4.44e-6 AD=1.5984e-12 AS=2.664e-12 PD=720e-9 PS=5.64e-6 M=1
m994 vdd! n39 n42 vdd! pmos L=240e-9 W=4.44e-6 AD=2.664e-12 AS=1.5984e-12 PD=5.64e-6 PS=720e-9 M=1
m995 n42 n39 vdd! vdd! pmos L=240e-9 W=4.44e-6 AD=1.5984e-12 AS=2.664e-12 PD=720e-9 PS=5.64e-6 M=1
m996 n38 n15 d vdd! pmos L=240e-9 W=5.64e-6 AD=3.384e-12 AS=2.0304e-12 PD=6.84e-6 PS=720e-9 M=1
m997 d n15 n38 vdd! pmos L=240e-9 W=5.64e-6 AD=2.0304e-12 AS=2.0304e-12 PD=720e-9 PS=720e-9 M=1
m998 n38 n15 d vdd! pmos L=240e-9 W=5.64e-6 AD=2.0304e-12 AS=2.0304e-12 PD=720e-9 PS=720e-9 M=1
m999 d n15 n38 vdd! pmos L=240e-9 W=5.64e-6 AD=2.0304e-12 AS=2.0304e-12 PD=720e-9 PS=720e-9 M=1
m1000 n38 n15 d vdd! pmos L=240e-9 W=5.64e-6 AD=2.0304e-12 AS=2.0304e-12 PD=720e-9 PS=720e-9 M=1
m1001 d n15 n38 vdd! pmos L=240e-9 W=5.64e-6 AD=2.0304e-12 AS=2.0304e-12 PD=720e-9 PS=720e-9 M=1
m1002 n38 n15 d vdd! pmos L=240e-9 W=5.64e-6 AD=2.0304e-12 AS=2.0304e-12 PD=720e-9 PS=720e-9 M=1
m1003 d n15 n38 vdd! pmos L=240e-9 W=5.64e-6 AD=2.0304e-12 AS=3.384e-12 PD=720e-9 PS=6.84e-6 M=1
m1004 n45 0 vdd! vdd! pmos L=240e-9 W=360e-9 AD=273.6e-15 AS=158.4e-15 PD=1.8e-6 PS=840e-9 M=1
m1005 vdd! 0 n40 vdd! pmos L=240e-9 W=360e-9 AD=158.4e-15 AS=273.6e-15 PD=840e-9 PS=1.8e-6 M=1
m1006 n35 0 vdd! vdd! pmos L=240e-9 W=360e-9 AD=273.6e-15 AS=158.4e-15 PD=1.8e-6 PS=840e-9 M=1
m1007 vdd! 0 n32 vdd! pmos L=240e-9 W=360e-9 AD=158.4e-15 AS=273.6e-15 PD=840e-9 PS=1.8e-6 M=1
m1008 n39 n36 vdd! vdd! pmos L=240e-9 W=2.52e-6 AD=1.512e-12 AS=1.512e-12 PD=3.72e-6 PS=3.72e-6 M=1
m1009 n31 n12 d vdd! pmos L=240e-9 W=3.84e-6 AD=2.304e-12 AS=1.3824e-12 PD=5.04e-6 PS=720e-9 M=1
m1010 d n12 n31 vdd! pmos L=240e-9 W=3.84e-6 AD=1.3824e-12 AS=1.3824e-12 PD=720e-9 PS=720e-9 M=1
m1011 n31 n12 d vdd! pmos L=240e-9 W=3.84e-6 AD=1.3824e-12 AS=1.3824e-12 PD=720e-9 PS=720e-9 M=1
m1012 d n12 n31 vdd! pmos L=240e-9 W=3.84e-6 AD=1.3824e-12 AS=2.304e-12 PD=720e-9 PS=5.04e-6 M=1
m1013 n11 rst vdd! vdd! pmos L=240e-9 W=2.46e-6 AD=1.476e-12 AS=1.476e-12 PD=3.66e-6 PS=3.66e-6 M=1
m1014 n10 c2 vdd! vdd! pmos L=240e-9 W=2.46e-6 AD=1.476e-12 AS=1.476e-12 PD=3.66e-6 PS=3.66e-6 M=1
m1015 n9 c1 vdd! vdd! pmos L=240e-9 W=2.46e-6 AD=1.476e-12 AS=1.476e-12 PD=3.66e-6 PS=3.66e-6 M=1

vvdd vdd! 0 2.5

vclk clk 0 PULSE(0 2.5 1n 300p 300p 2.5n 5n)
vrst rst 0 PULSE(0 2.5 17n 2n 2n 185n 205n)
vc1 c1 0 0
vc2 c2 0 2.5
cd d 0 8p

.tran 1ps 251ns
.option post
.END
